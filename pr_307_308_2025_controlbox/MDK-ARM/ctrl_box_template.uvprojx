# Keil uVision project ctrl_box_template.uvprojx, settings and files
target ctrl_box_template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.4
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pr_307_l3 +hex
  AfterMake: fromelf.exe --bin -o  ./pr_307_l3/bin/  ./pr_307_l3/@L.axf
  AfterMake: .\pr_307_l3\bin\CreateFinalBin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,UI_PLATFORM_MCU,ETH_INTERFACE_RMII,PROJECT_TYPE=307
  c misc: --locale=english
  c include: ..\CMSIS;.\pr_307_l3\bin;..\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\Third_Party\FreeRTOS\Source\include;..\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Third_Party\perf_counter;..\Hal_Mcu\Include;..\Application;..\MDK-ARM;..\HC32F4A0x_standard_peripheral\Include;..\CMSIS\common;..\Third_Party\lvgl;..\Component\lcd;..\Application\GUI;..\Application\GUI\img;..\Component\os_ev;..\Third_Party\lwip\src\include;..\Third_Party\lwip\port;..\Third_Party\security;..\Drivers;..\Third_Party\dmx-profile-analysis-master;..\Third_Party\fat_fs;..\Midware;..\Devices;..\Component\sACN;..\Component\artnet;..\Component\iot;..\Component\update_module;..\Component\Littlefs\Include;..\Component\SidusProFX;..\Component\sys_delay;..\Component\rdm;..\Third_Party\lfm;..\Third_Party\sm4;..\HC32F4A0x_usbfs_library\usb_host\host_class_t;..\HC32F4A0x_usbfs_library\usb_host\host_core_t;..\HC32F4A0x_usbfs_library\usb_host\host_class_t\hid;..\HC32F4A0x_usbfs_library\usb_host\host_class_t\msc;..\HC32F4A0x_usbfs_library\usb_host\usb_config;..\Third_Party\fat_fs
  library: MicroLIB
  memory RVCT1: ROM 0x16000 size 0x2000
  memory RVCT2: ROM 0x98000000 size 0x200000
  memory RVCT4: ROM 0x18000 size 0x1e0000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x7ff00
  group Application
    ../Application/: app_dmx.c app_gui.c app_eth.c main.c app_artnet.c app_usb.c app_data_center.c app_ble.c app_ble_protocol_parse.c api_gatt_proto.c user_sacn.c app_ble_port.c app_ota.c app_basic_data.c project_config.h project_def.h local_data.h irq.h app_err_detect.c app_wdt.c app_power.c app_light.c app_light_data_analyze.c api_rs485_proto .c app_dac_self_adapt.c
    ./pr_307_l3/bin/: version.h
  group GUI\app
    ../Application/GUI/: font.c lang.c lv_user.c menu_item_obj.c page.c page_cct.c page_cctsetting.c page_dropdown.c page_gel.c page_gelsetting.c page_hsi.c page_hsisetting.c page_lighteffect.c page_lowpower.c page_manager.c page_menu.c page_mixplug.c page_pool.c page_presettask.c page_rgb.c page_rgbsetting.c page_screenprotector.c page_sidusprofx.c page_source.c page_sourcesetting.c page_widget.c page_xy.c page_xysetting.c practice1.c preset_task_item.c ui_common.c ui_data.c ui_indev.c user.c ui_assets.c ui_hal.c base_type.h ui_config.h unit.h user.h page_i_fire.c
    ../Application/GUI/test/: page_uitest.c
    ../Application/GUI/system_menu/: page_batteryoption.c page_controlsystem.c page_customfx.c page_dimmingcurve.c page_dmxmode.c page_factoryreset.c page_fanmode.c page_language.c page_frequencysel.c page_msgbox.c page_outpumode.c page_overheat.c page_productinfo.c page_screensavar.c page_studiomode.c page_update.c page_workmode.c sysmenuwidget.c page_hsmode.c page_moveset.c page_highspeedmode.c page_accessory.c page_hs_window.c
    ../Application/GUI/light_effect/: lighteffect_widget.c page_candle.c page_cctlimitsetting.c page_clublights.c page_colorchase.c page_copcar.c page_explosion.c page_faultybulb.c page_fire.c page_fireworks.c page_hsilimitsetting.c page_lightning.c page_paparazzi.c page_partylight.c page_pulsing.c page_strobe.c page_tv.c page_welding.c
    ../Application/GUI/light_effect/version_i/: page_i_explosion.c page_i_faultybulb.c page_i_fireworks.c page_i_lightning.c page_i_paparazzi.c page_i_pulsing.c page_i_strobe.c page_i_tv.c
    ../Application/GUI/calibration_mode/: page_calibration_mode.c
  group Hal_Mcu
    ../HAL_MCU/Source/: board.c hal_gpio.c hal_flash.c hal_irq.c hal_eth.c hal_qspi.c hal_adc.c hal_timer.c hal_iic.c hal_spi.c hal_key.c hal_uart.c hal_wdt.c
    ../HC32F4A0x_standard_peripheral/Source/: hc32f4a0_usb_core_driver.c
  group CMSIS
    ../CMSIS/common/: system_hc32f4a0.c
    ../CMSIS/MDK/: startup_hc32f4a0.s
  group Component\lcd
    ../Component/lcd/: lcd.c
    ../Component/lcd/port/: lcd_bsp.c lcd_smc.c
    ../Component/lcd/dev/: gc9307.c
  group Component\os_ev
    ../Component/os_ev/: os_event.c
  group Component\artnet
    ../Component/artnet/: artnet.c artnet_misc.c network.c receive.c tod.c transmit.c
  group Component\sACN
    ../Component/sACN/: e131.c
  group Component\update_module
    ../Component/update_module/: update_module.c
  group Component\littlefs
    ../Component/Littlefs/Source/: lfs.c lfs_flash.c lfs_util.c
  group Component\iot
    ../Component/iot/: iot_dispose.c
  group Component\hardfault
    ../Component/hardfault_probe/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Component\SsdusProFx
    ../Component/SidusProFX/: SidusPro_Interface.c SidusProFile.c SidusProFX.c
  group Component\sys_delay
    ../Component/sys_delay/: sys_delay.c
  group Component\rdm
    ../Component/rdm/: app_rdm.c
  group hc32f4a0x_standard_peripheral
    ../HC32F4A0x_standard_peripheral/Source/: hc32f4a0_usart.c hc32f4a0_dma.c hc32f4a0_gpio.c hc32f4a0_utility.c hc32f4a0_interrupts.c hc32f4a0_tmr0.c hc32f4a0_pwc.c hc32f4a0_clk.c hc32f4a0_efm.c hc32f4a0_sram.c hc32f4a0_smc.c hc32f4a0_eth.c hc32f4a0_qspi.c hc32f4a0_tmr2.c hc32f4a0_dac.c hc32f4a0_adc.c hc32f4a0_tmr6.c hc32f4a0_tmra.c hc32f4a0_i2c.c hc32f4a0_spi.c hc32f4a0_wdt.c
  group Third_Party\FreeRTOS
    ../Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Third_Party\perf_counter
    ../Third_Party/perf_counter/: perf_counter.c systick_wrapper_ual.s
  group Third_Party\lvgl
    ../Third_Party/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Third_Party/lvgl/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Third_Party/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Third_Party/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Third_Party/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Third_Party/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Third_Party/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Third_Party/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Third_Party/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Third_Party/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../Third_Party/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Third_Party/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../Third_Party/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Third_Party/lvgl/lvgl/src/extra/: lv_extra.c
    ../Third_Party/lvgl/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c
    ../Third_Party/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Third_Party/lvgl/lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Third_Party/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Third_Party\fat_fs
    ../Third_Party/fat_fs/: fattime.c ff.c ffunicode.c gen_drv.c diskio.c cc936.c
  group Third_Party\security
    ../Third_Party/security/: aes.c security.c security_encrypt.c security_user_implement.c
  group Third_Party\lwip
    ../Third_Party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Third_Party/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Third_Party/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Third_Party/lwip/src/netif/: ethernet.c
  group Third_Party\dmx_profile
    ../Third_Party/dmx-profile-analysis-master/: dmx_profile_analysis.c
  group GUI\fonts
    ../Application/GUI/font/: MisansMedium18.c ArialUni6.c ArialUni8.c ArialUni11.c ArialUni11_S.c ArialUni12.c ArialUni13.c ArialUni13Up.c ArialUni15.c ArialUni18.c ArialUni22.c ArialUni26.c ArialUni32.c ArialUni38.c ArialUni48.c FixedSys11.c MisansBold10.c MisansBold12.c MisansBold14.c MisansBold16.c MisansBold18.c MisansBold22.c MisansBold24.c MiSansDemiBold49.c MiSansHeavy14.c MisansMedium10.c MisansMedium12.c MisansMedium14.c MisansMedium16.c MisansMedium22.c MisansMedium24.c MiSansRegular9.c MisansRegular10.c MiSansHeavy18.c MisansBold13.c
  group GUI\images
    ../Application/GUI/img/: ImgConfirmFailed.c ImgConfirmOk.c ImgExplosion.c ImgFaultyBulb.c ImgFire.c ImgLightning.c ImgPaparazzi.c ImgParty.c ImgPulsing.c ImgStrobe.c ImgTV.c ImgCandle.c ImgColorChase.c ImgClubLights.c ImgCopCar.c ImgFireWorks.c ImgWelding.c ImgCtrlSystem.c ImgCustomFX.c ImgDimCurve.c ImgDMXMode.c ImgFactoryReset.c ImgFanMode.c ImgHighSpdMode.c ImgLanguage.c ImgMasterMode.c ImgOutputMode.c ImgProductInfo.c ImgUpdate.c ImgFreSelect.c img_Electric.c ImgBatteryOption.c ImgWorkMode.c ImgScreenSaver.c ImgStudioMode.c ImgArrowLeft.c ImgOutput.c imgStart.c imgStop.c
  group hc32f4a0x_usb_lib\midware
    ../HC32F4A0x_usbfs_library/usb_host/host_class_t/hid/: usb_host_hid_class.c usb_host_hid_keyboardapp.c usb_host_hid_mouseapp.c
    ../HC32F4A0x_usbfs_library/usb_host/host_class_t/msc/: usb_host_msc_bot.c usb_host_msc_class.c usb_host_msc_fatfs.c usb_host_msc_scsi.c
    ../HC32F4A0x_usbfs_library/usb_host/host_core_t/: usb_host_cfgch.c usb_host_core.c usb_host_ctrltrans.c usb_host_driver.c usb_host_int.c usb_host_stdreq.c
  group hc32f4a0x_usb_lib\config
    ../HC32F4A0x_usbfs_library/usb_host/usb_config/: usb_bsp.c usb_host_user.c
  group midware
    ../Midware/: CRC32.c
  group GUI\port
    ../Third_Party/lvgl/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group Drivers
    ../Drivers/: dev_ble.c dev_w25qxx.c dev_rs485.c dev_adapter.c dev_power.c dev_crmx.c dev_fan.c dev_lumenradio_api.c dev_lumenradio_drive.c dev_pwm_self.c
  group lwip\port
    ../Third_Party/lwip/port/OS/: sys_arch.c
    ../Third_Party/lwip/port/: app_ethernet.c ethernetif.c
  group ex_flash
    ../Application/GUI/img/: cct_img.c img_Adapter.c img_Dc.c img_Dca.c img_Dcb.c img20Reflector.c img30Reflector.c img50Reflector.c ImgAC.c ImgBarDot.c ImgBatteryFrame.c ImgBatteryTime.c ImgBattLeftFlag.c ImgBattRightFlag.c ImgBle.c ImgBle_B.c ImgBtnOFF.c ImgBtnON.c ImgCCT.c ImgCCTSelector.c ImgChargeIcon.c ImgChargingLightning.c ImgCRMXReset.c ImgCurveExp.c ImgCurveExp_L.c ImgCurveLinear.c ImgCurveLinear_L.c ImgCurveLog.c ImgCurveLog_L.c ImgCurveMain.c ImgCurveSShape.c ImgCurveSShape_L.c ImgDmxSmooth.c ImgDMXTeminationIcon_B.c ImgDMXTeminationIcon_L.c ImgDot.c ImgFanMode1.c ImgFanModeHigh_B.c ImgFanModeHigh_CH.c ImgFanModeHigh_EN.c ImgFanModeMedium_CH.c ImgFanModeMedium_EN.c ImgFanModeMid_B.c ImgFanModeSilent_B.c ImgFanModeSilent_CH.c ImgFanModeSilent_EN.c ImgFanModeSmart_B.c ImgFanModeSmart_CH.c ImgFanModeSmart_EN.c ImgFxFrq.c ImgHighSpeed.c ImgHSIFigure.c ImgHSISelector.c ImgIntCircle.c ImgLan.c ImgLightEffectBg.c ImgLock.c ImgLoopIcon.c ImgLowPowerBg.c ImgLowPowerExclamation.c ImgNextArraw.c ImgNoSignal.c ImgOverHeat.c ImgPan.c ImgPowerEnergy.c ImgPowerSupplyBox.c ImgPresetCandle.c ImgPresetClubLights.c ImgPresetColorChase.c ImgPresetCopcar.c ImgPresetExplosion.c ImgPresetFaultyBulb.c ImgPresetFire.c ImgPresetFireoworks.c ImgPresetLightning.c ImgPresetPaparazzi.c ImgPresetPapartyLights.c ImgPresetPulsing.c ImgPresetStrobe.c ImgPresetTV.c ImgPresetWelding.c ImgPulseIcon.c ImgRadioboxNoSel.c ImgRadioboxSel.c ImgReset.c ImgRGBColorfulBar.c ImgScreenProctector.c ImgSettingIcon.c ImgSidusproFX.c ImgStopIcon.c ImgStudioLight.c ImgStudioOff.c ImgStudioOn.c ImgStudioPerson.c ImgSwitchOff.c ImgSwitchOn.c ImgTestBg.c ImgTestZoom.c ImgTilt.c ImgTirangle.c ImgUnlock.c ImgUpdateArrow.c ImgWait1.c ImgWait2.c ImgWait3.c ImgWait4.c ImgWait5.c ImgWait6.c ImgWait7.c ImgWifi.c ImgXY.c ImgNoSignal1.c ImgNoSignal2.c ImgNoSignal3.c ImgNoWifi.c ImgNoWifi1.c ImgNoWifi2.c ImgNoWifi3.c ImgWifi1.c ImgWifi2.c ImgWifi3.c ImgWait8.c ImgFollowMode.c ImgLeadMode.c Img20Reflector2.c Img20ReflectorName.c Img30Reflector2.c Img30ReflectorName.c Img50Reflector2.c Img50ReflectorName.c imgAdaptorRing.c img_Indoor_power.c imgElliptic.c imgPowerCoor.c imgBreak.c img1s.c img2s.c img3s.c imgCoor.c
    ../Application/GUI/font/: Imgleftbox.c Imgrightbox.c
  group Third_Party\lfm
    ../Third_Party/lfm/: lfm_core.c lfm_port.c
software components: CMSIS:CORE 5.3.0
