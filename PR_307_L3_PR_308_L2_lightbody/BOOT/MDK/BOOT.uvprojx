# Keil uVision project BOOT.uvprojx, settings and files
target PR_308_L2_BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.4
  cpu: IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) IRAM(0x1FFE0000,0x80000) IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: PR_308_L2_BOOT
  AfterMake: fromelf --bin -o  ./Objects/BIN/@L.bin  ./Objects/@L/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,PR_308_L2_BOOT
  c misc: --diag_suppress=186,66
  c include: ..\source;..\common;..\driver\inc;..\USER\SystemClock
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x16000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x17e00
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f4a0.s
    ../common/: system_hc32f4a0.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: hc32f4a0_clk.c hc32f4a0_efm.c hc32f4a0_gpio.c hc32f4a0_sram.c hc32f4a0_utility.c hc32f4a0_icg.c hc32f4a0_crc.c
  group User
    ../USER/SystemClock/: SystemClock.c
  group Readme
    ../: Readme.txt
target PR_307_L3_BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.4
  cpu: as above
  output: PR_307_L3_BOOT
  AfterMake: fromelf --bin -o  ./Objects/BIN/@L.bin  ./Objects/@L/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,PR_307_L3_BOOT
  c misc: --diag_suppress=186,66
  c include: ..\source;..\common;..\driver\inc;..\USER\SystemClock
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x16000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x17e00
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
