# Keil uVision project APP.uvprojx, settings and files
target PR_308_L2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.4
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PR_308_L2 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: .\Objects\@L\@L.bin\CreateFinalBin.bat @L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,PR_308_L2
  c misc: --wchar16 --fp16_format=ieee
  c include: ..\source;..\driver\inc;..\common;..\bsp\Include;..\source\bsp;..\source\app;..\lib\security;..\lib\sys;..\lib\rs485_Slave;..\lib\Rs485_Proto_II;..\lib\algorithm;..\lib\led_mixing;..\lib\light_effect;..\lib\SidusProFX;..\lib\define;..\lib\other;..\lib\app;..\lib\littleFs;..\lib\mpu6050;..\lib\lsm16x;..\lib\electronic;..\lib\iot;..\MDK
  library: MicroLIB
  memory RVCT1: ROM 0x18000 size 0x2000
  memory RVCT4: ROM 0x1a000 size 0x16000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x7ff00
  scatter file: .\Objects\PR_307_L3.sct
  link misc: --keep=*Handler
  group common
    ../common/: system_hc32f4a0.c
    ./: startup_hc32f4a0.s
  group source
    ../source/: main.c
  group app
    ../lib/app/: app_adc.c app_ctr.c app_led.c app_task.c app_store.c
  group driver
    ../driver/src/: hc32f4a0_adc.c hc32f4a0_aes.c hc32f4a0_can.c hc32f4a0_clk.c hc32f4a0_cmp.c hc32f4a0_crc.c hc32f4a0_ctc.c hc32f4a0_dac.c hc32f4a0_dcu.c hc32f4a0_dma.c hc32f4a0_dmc.c hc32f4a0_dvp.c hc32f4a0_efm.c hc32f4a0_emb.c hc32f4a0_eth.c hc32f4a0_event_port.c hc32f4a0_fcm.c hc32f4a0_fmac.c hc32f4a0_gpio.c hc32f4a0_hash.c hc32f4a0_hrpwm.c hc32f4a0_i2c.c hc32f4a0_i2s.c hc32f4a0_icg.c hc32f4a0_interrupts.c hc32f4a0_keyscan.c hc32f4a0_mau.c hc32f4a0_mpu.c hc32f4a0_nfc.c hc32f4a0_ots.c hc32f4a0_pwc.c hc32f4a0_qspi.c hc32f4a0_rmu.c hc32f4a0_rtc.c hc32f4a0_sdioc.c hc32f4a0_smc.c hc32f4a0_spi.c hc32f4a0_sram.c hc32f4a0_swdt.c hc32f4a0_tmr0.c hc32f4a0_tmr2.c hc32f4a0_tmr4.c hc32f4a0_tmr6.c hc32f4a0_tmra.c hc32f4a0_trng.c hc32f4a0_usart.c hc32f4a0_utility.c hc32f4a0_wdt.c
  group dsp
    ../source/bsp/: bsp_init.c bsp_rs485.c bsp_wdt.c bsp_debug.c bsp_power.c bsp_fan.c bsp_adc.c bsp_usart.c bsp_timer.c bsp_flash.c bsp_iic.c bsp_w25qxx_q.c bsp_mpu6050.c
  group security
    ../lib/security/: aes.c security.c security_encrypt.c security_user_implement.c
  group sys
    ../lib/sys/: crc_32.c delay.c task.c
  group Rs485_II
    ../lib/Rs485_Proto_II/: Rs485_Proto_Slave_Ack.c Rs485_Proto_Slave_Analysis.c Rs485_Proto_Slave_Recv.c
  group rs485_Slave
    ../lib/rs485_Slave/: base_data_rs485.c rs485.c
  group algorithm
    ../lib/algorithm/: algorithm.c data_acc.c data_cmp.c data_convert.c data_fill.c data_find.c data_shift.c sort_algorithm.c
  group led_mixing
    ../lib/led_mixing/: base_data.c color_mixing_dev.c color_mixing_FP.lib
  group light_effect
    ../lib/light_effect/: light_effect_interface.c light_effect.c
  group sidus_pro
    ../lib/SidusProFX/: CRC32.c FIFO.c SidusPro_Interface.c SidusProFile.c SidusProFX.c
  group define
    ../lib/define/: define.c
  group other
    ../lib/other/: fan.c flash.c systick.c upgrade.c upgrade_list.c
  group littleFs
    ../lib/littleFs/: lfs.c lfs_flash.c lfs_util.c
  group mpu6050
    ../lib/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group lsm16x
    ../lib/lsm16x/: lsm16x_iic.c lsm6dsv16x_fifo_irq.c lsm6dsv16x_reg.c lsm6dsv16x_fifo.c
  group electronic
    ../lib/electronic/: bsp_electronic.c sm4_enc_user.c sm4_encryption.c
  group module.iot
    ../lib/iot/: iot_dispose.c
target PR_307_L3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.4
  cpu: as above
  output: PR_307_L3 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: .\Objects\@L\@L.bin\CreateFinalBin.bat @L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,PR_307_L3
  c misc: --wchar16 --fp16_format=ieee
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x18000 size 0x2000
  memory RVCT4: ROM 0x1a000 size 0x16000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x7ff00
  scatter file: .\Objects\PR_307_L3.sct
  link misc: --keep=*Handler
